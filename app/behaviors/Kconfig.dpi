## app/behaviors/Kconfig.dpi
```kconfig
config ZMK_BEHAVIOR_DPI_CYCLE
    bool "Enable DPI Cycle behavior"
    default y
```
